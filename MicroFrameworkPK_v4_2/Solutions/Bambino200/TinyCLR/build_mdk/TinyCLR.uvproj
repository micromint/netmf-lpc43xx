# Keil uVision project TinyCLR.uvproj, settings and files
target TinyCLR - Release (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: TinyCLR +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1
  c misc: --via=ccflags-release.txt
  asm misc: --via=asflags-release.txt
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x10080000 size 0x12000
  scatter file: TinyCLR.sct
  link misc: --via=ldflags-release.txt
  group Source
    ../: TinyCLR.cpp allocator.cpp
    ../../DeviceCode/BlockStorage/AddDevices/: Bl_AddDevices.cpp
    ../../DeviceCode/Init/: IO_Init.cpp
    ../../DeviceCode/BlockStorage/LPC43XX/: LPC43XX_BlConfig.cpp
    ../../DeviceCode/USB/: usb_config.cpp
    ./: CLR_RT_InteropAssembliesTable.cpp
    ../RVD_S/: tinyclr_dat.s
  group Docs
    ../../../../DeviceCode/Targets/Native/LPC43XX/: README.txt
    ./: TinyCLR.sct
  group CLR-Core
    ../../../../CLR/Core/: AVLTree.cpp Cache.cpp Checks.cpp CLR_RT_DblLinkedList.cpp CLR_RT_HeapBlock.cpp CLR_RT_HeapBlock_Array.cpp CLR_RT_HeapBlock_ArrayList.cpp CLR_RT_HeapBlock_BinaryBlob.cpp CLR_RT_HeapBlock_Delegate.cpp CLR_RT_HeapBlock_Delegate_List.cpp CLR_RT_HeapBlock_Finalizer.cpp CLR_RT_HeapBlock_Lock.cpp CLR_RT_HeapBlock_LockRequest.cpp CLR_RT_HeapBlock_Node.cpp CLR_RT_HeapBlock_Queue.cpp CLR_RT_HeapBlock_Stack.cpp CLR_RT_HeapBlock_String.cpp CLR_RT_HeapBlock_Timer.cpp CLR_RT_HeapBlock_WaitForObject.cpp CLR_RT_HeapCluster.cpp CLR_RT_Interop.cpp CLR_RT_Memory.cpp CLR_RT_MemoryRange.cpp CLR_RT_ObjectToEvent_Destination.cpp CLR_RT_ObjectToEvent_Source.cpp CLR_RT_RuntimeMemory.cpp CLR_RT_StackFrame.cpp CLR_RT_SystemAssembliesTable.cpp CLR_RT_UnicodeHelper.cpp core.cpp Execution.cpp GarbageCollector.cpp GarbageCollector_Compaction.cpp GarbageCollector_ComputeReachabilityGraph.cpp GarbageCollector_Info.cpp Interpreter.cpp Random.cpp Streams.cpp StringTable.cpp Thread.cpp TypeSystem.cpp TypeSystemLookup.cpp Various.cpp
    ../../../../CLR/Core/Serialization/: BinaryFormatter.cpp
    ../../../../CLR/Core/RPC/: CLR_RT_HeapBlock_EndPoint.cpp
    ../../../../CLR/Core/I2C/: CLR_RT_HeapBlock_I2CXAction.cpp
    ../../../../CLR/Core/IOPort/: CLR_RT_HeapBlock_IOPort.cpp
    ../../../../CLR/Core/Stream/: FileStream.cpp
    ../../../../CLR/Core/Hardware/: Hardware.cpp
    ../../../../CLR/Core/Hardware/InterruptHandler/: InterruptHandler.cpp
    ../../../../CLR/Core/HeapPersistence/: Heap_Persistence.cpp
    ../../../../CLR/Core/Xml/: XmlCharRef.cpp XmlCharType.cpp XmlNameTable.cpp XmlReader.cpp XmlState.cpp XmlState_BetweenElements.cpp XmlState_InAttribute.cpp XmlState_InAttributeValue.cpp XmlState_InEndElement.cpp XmlState_InName.cpp XmlState_InProcessingInstruction.cpp XmlState_InStartElement.cpp XmlState_InValue.cpp XmlState_InXmlDeclaration.cpp XmlState_NewTag.cpp XmlState_Start.cpp
  group CLR-Debugger
    ../../../../CLR/Debugger/: Debugger.cpp Debugger_full.cpp
  group CLR-Diagnostics
    ../../../../CLR/Diagnostics/: Info.cpp Profile.cpp Profiler.cpp
  group CLR-Graphics
    ../../../../CLR/Graphics/: graphics_stub.cpp
  group CLR-Lib-CorLib
    ../../../../CLR/Libraries/CorLib/: corlib_native.cpp corlib_native_System_AppDomain.cpp corlib_native_System_Array.cpp corlib_native_System_Attribute.cpp corlib_native_System_Collections_ArrayList.cpp corlib_native_System_Collections_Queue.cpp corlib_native_System_Collections_Stack.cpp corlib_native_System_DateTime.cpp corlib_native_System_Delegate.cpp corlib_native_System_Diagnostics_Debugger.cpp corlib_native_System_Double.cpp corlib_native_System_Enum.cpp corlib_native_System_Exception.cpp corlib_native_System_GC.cpp corlib_native_System_Globalization_CultureInfo.cpp corlib_native_System_Globalization_DateTimeFormat.cpp corlib_native_System_Globalization_DaylightTime.cpp corlib_native_System_MarshalByRefObject.cpp corlib_native_System_Math.cpp corlib_native_System_MulticastDelegate.cpp corlib_native_System_Number.cpp corlib_native_System_Object.cpp corlib_native_System_Random.cpp corlib_native_System_Reflection_Assembly.cpp corlib_native_System_Reflection_Binder.cpp corlib_native_System_Reflection_ConstructorInfo.cpp corlib_native_System_Reflection_FieldInfo.cpp corlib_native_System_Reflection_MemberInfo.cpp corlib_native_System_Reflection_MethodBase.cpp corlib_native_System_Reflection_PropertyInfo.cpp corlib_native_System_Reflection_RuntimeFieldInfo.cpp corlib_native_System_Reflection_RuntimeMethodInfo.cpp corlib_native_System_Resources_ResourceManager.cpp corlib_native_System_Runtime_CompilerServices_RuntimeHelpers.cpp corlib_native_System_Runtime_Remoting_RemotingServices.cpp corlib_native_System_RuntimeType.cpp corlib_native_System_String.cpp corlib_native_System_SystemException.cpp corlib_native_System_Text_UTF8Decoder.cpp corlib_native_System_Text_UTF8Encoding.cpp corlib_native_System_Threading_AutoResetEvent.cpp corlib_native_System_Threading_Interlocked.cpp corlib_native_System_Threading_ManualResetEvent.cpp corlib_native_System_Threading_Monitor.cpp corlib_native_System_Threading_Thread.cpp corlib_native_System_Threading_ThreadAbortException.cpp corlib_native_System_Threading_Timer.cpp corlib_native_System_Threading_WaitHandle.cpp corlib_native_System_TimeSpan.cpp corlib_native_System_TimeZone.cpp corlib_native_System_Type.cpp corlib_native_System_ValueType.cpp corlib_native_System_WeakReference.cpp
  group CLR-Lib-SPOT
    ../../../../CLR/Libraries/SPOT/: spot_native.cpp spot_native_Microsoft_SPOT_Debug.cpp spot_native_Microsoft_SPOT_ExecutionConstraint.cpp spot_native_Microsoft_SPOT_ExtendedTimer.cpp spot_native_Microsoft_SPOT_ExtendedWeakReference.cpp spot_native_Microsoft_SPOT_Hardware_SystemInfo.cpp spot_native_Microsoft_SPOT_Hardware_SystemInfo__SystemID.cpp spot_native_Microsoft_SPOT_Hardware_Utility.cpp spot_native_Microsoft_SPOT_Math.cpp spot_native_Microsoft_SPOT_Reflection.cpp spot_native_Microsoft_SPOT_ResourceUtility.cpp spot_native_Microsoft_SPOT_SerializationHintsAttribute.cpp spot_native_Microsoft_SPOT_UnknownTypeException.cpp spot_native_Microsoft_SPOT_WeakDelegate.cpp spot_native_System_Security_Cryptography_X509Certificates_X509Certificate.cpp
    ../../../../CLR/Libraries/SPOT/SPOT_Messaging/: spot_native_Microsoft_SPOT_Messaging_EndPoint.cpp spot_native_Microsoft_SPOT_Messaging_Message.cpp spot_native_Microsoft_SPOT_Messaging_Message__RemotedException.cpp
    ../../../../CLR/Libraries/SPOT/SPOT_Serialization/: spot_native_Microsoft_SPOT_Serialization.cpp
    ../../../../CLR/Libraries/SPOT_Hardware/: spot_hardware_native.cpp spot_hardware_native_Microsoft_SPOT_EventSink.cpp spot_hardware_native_Microsoft_SPOT_Hardware_AnalogInput.cpp spot_hardware_native_microsoft_spot_hardware_AnalogOutput.cpp spot_hardware_native_Microsoft_SPOT_Hardware_Battery.cpp spot_hardware_native_Microsoft_SPOT_Hardware_Battery__ChargerModel.cpp spot_hardware_native_Microsoft_SPOT_Hardware_Cpu.cpp spot_hardware_native_Microsoft_SPOT_Hardware_HardwareProvider.cpp spot_hardware_native_Microsoft_SPOT_Hardware_I2CDevice.cpp spot_hardware_native_Microsoft_SPOT_Hardware_I2CDevice__Configuration.cpp spot_hardware_native_Microsoft_SPOT_Hardware_InputPort.cpp spot_hardware_native_Microsoft_SPOT_Hardware_InterruptPort.cpp spot_hardware_native_Microsoft_SPOT_Hardware_LargeBuffer.cpp spot_hardware_native_Microsoft_SPOT_Hardware_NativeEventDispatcher_mshl.cpp spot_hardware_native_Microsoft_SPOT_Hardware_OutputPort.cpp spot_hardware_native_Microsoft_SPOT_Hardware_Port.cpp spot_hardware_native_Microsoft_SPOT_Hardware_PowerState.cpp spot_hardware_native_Microsoft_SPOT_Hardware_SPI.cpp spot_hardware_native_Microsoft_SPOT_Hardware_SPI__Configuration.cpp spot_hardware_native_Microsoft_SPOT_Hardware_TristatePort.cpp spot_hardware_native_Microsoft_SPOT_Hardware_Watchdog.cpp
    ../../../../CLR/Libraries/SPOT_Hardware/SPOT_PWM/: spot_hardware_pwm_native.cpp spot_hardware_pwm_native_Microsoft_spot_hardware_PWM.cpp
    ../../../../CLR/Libraries/SPOT_Hardware/SPOT_Serial/: spot_hardware_serial_native.cpp spot_hardware_serial_native_Microsoft_spot_hardware_SerialPort_events.cpp spot_hardware_serial_native_System_IO_Ports_SerialPort.cpp
    ../../../../CLR/Libraries/SPOT_Hardware/SPOT_Usb/: spot_hardware_usb_native.cpp spot_hardware_usb_native_Microsoft_SPOT_Hardware_UsbClient_UsbController.cpp spot_hardware_usb_native_Microsoft_SPOT_Hardware_UsbClient_UsbStream.cpp
    ../../../../CLR/Libraries/SPOT_IO/: spot_io_native.cpp spot_io_native_Microsoft_SPOT_IO_NativeFileStream.cpp spot_io_native_Microsoft_SPOT_IO_NativeFindFile.cpp spot_io_native_Microsoft_SPOT_IO_NativeIO.cpp spot_io_native_Microsoft_SPOT_IO_RemovableMedia.cpp spot_io_native_Microsoft_SPOT_IO_VolumeInfo.cpp
    ../../../../CLR/Libraries/SPOT_Update/: spot_update_native.cpp spot_update_native_Microsoft_SPOT_MFUpdate_MFNativeUpdate.cpp
  group CLR-Lib-System
    ../../../../CLR/StartupLib/: CLRStartup.cpp
    ../../../../CLR/Messaging/: Messaging.cpp
    ../../../../CLR/Libraries/System_Xml/: system_xml_native.cpp system_xml_native_System_Xml_XmlNameTable.cpp system_xml_native_System_Xml_XmlReader.cpp
  group Device-Target
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/CortexM/TinyHal/: Aborts.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/CortexM/GlobalLock/: SmartPtr_cortex.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_AD/: LPC43XX_AD.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_Bootstrap/: LPC43XX_Bootstrap.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_DA/: LPC43XX_DA.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_GPIO/: LPC43XX_GPIO.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_I2C/: LPC43XX_I2C.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_INTC/: LPC43XX_INTC.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_IPC/: LPC43XX_IPC.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_Power/: LPC43XX_Power.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_PWM/: LPC43XX_PWM.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_SPI/: LPC43XX_SPI.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_SPIFI/: LPC43XX_SPIFI.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_Time/: LPC43XX_Time.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_USART/: LPC43XX_USART.cpp
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/LPC43XX_USB/: LPC43XX_USB.cpp
  group Device-PAL
    ../../../../DeviceCode/pal/BlockStorage/: blockstoragelist.cpp
    ../../../../DeviceCode/pal/COM/: ComDirector.cpp
    ../../../../DeviceCode/pal/AsyncProcCall/: Completions.cpp Continuations.cpp
    ../../../../DeviceCode/pal/configuration/: ConfigHelper.cpp
    ../../../../DeviceCode/pal/COM/Config/: DebuggerPort_SSL_config_stub.cpp
    ../../../../DeviceCode/pal/events/: events.cpp
    ../../../../DeviceCode/pal/fs/stubs/: fs_stubs.cpp
    ../../../../DeviceCode/pal/fs/stubs/Config/: FS_config_stubs.cpp
    ../../../../DeviceCode/pal/Gesture/stubs/: gesture_stubs.cpp
    ../../../../DeviceCode/pal/Buttons/: GPIO_Buttons.cpp GPIO_config.cpp
    ../../../../DeviceCode/pal/heap/: heap.cpp
    ../../../../DeviceCode/pal/COM/i2c/: i2c.cpp
    ../../../../DeviceCode/pal/Ink/stubs/: ink_stubs.cpp
    ../../../../DeviceCode/pal/MFUpdate/stubs/: MFUpdate_stub.cpp
    ../../../../DeviceCode/pal/Double/: native_double_pal.cpp
    ../../../../DeviceCode/pal/palevent/: palevent_driver.cpp palevent_functions.cpp
    ../../../../DeviceCode/pal/piezo/stubs/: piezo_stubs.cpp
    ../../../../DeviceCode/pal/SimpleHeap_config/stubs/: SimpleHeap_config_stubs.cpp
    ../../../../DeviceCode/pal/SimpleHeap/stubs/: SimpleHeap_stubs.cpp
    ../../../../DeviceCode/pal/COM/sockets/stubs/: sockets_stubs.cpp
    ../../../../DeviceCode/pal/COM/sockets/Ssl/stubs/: ssl_pal_stubs.cpp
    ../../../../DeviceCode/pal/timeservice/stubs/: timeservice_stubs.cpp
    ../../../../DeviceCode/pal/time/: time_driver.cpp time_functions.cpp
    ../../../../DeviceCode/pal/tinycrt/: tinycrt.cpp
    ../../../../DeviceCode/pal/COM/usart/: usart.cpp
    ../../../../DeviceCode/pal/COM/usb/: usb.cpp
    ../../../../DeviceCode/pal/watchdog/stubs/: Watchdog_stubs.cpp
  group Device-Drivers
    ../../../../DeviceCode/Drivers/Backlight/stubs/: backlight_stubs_config.cpp Backlight_stubs_functions.cpp
    ../../../../DeviceCode/Drivers/BatteryCharger/stubs/: BatteryCharger_stubs_config.cpp BatteryCharger_stubs_functions.cpp
    ../../../../DeviceCode/Drivers/BatteryMeasurement/stubs/: BatteryMeasurement_stubs_config.cpp BatteryMeas_stubs_functions.cpp
    ../../../../DeviceCode/Drivers/Display/stubs/: Display_stubs_config.cpp Display_stubs_functions.cpp
    ../../../../DeviceCode/Drivers/FS/FAT/: FAT_File.cpp FAT_FileHandle.cpp FAT_FS.cpp FAT_FS_Utility.cpp FAT_LogicDisk.cpp FAT_MemoryManager.cpp FAT_SectorCache.cpp fs.cpp
    ../../../../DeviceCode/Drivers/LargeBuffer/stubs/: LargeBuffer_stubs.cpp
    ../../../../DeviceCode/Drivers/Stubs/Processor/stubs_cache/: stubs_functions_cache.cpp
    ../../../../DeviceCode/Drivers/Stubs/Processor/stubs_EBIU/: stubs_functions_EBIU.cpp
    ../../../../DeviceCode/Drivers/Stubs/Processor/stubs_LCD/: stubs_functions_LCD.cpp
    ../../../../DeviceCode/Drivers/Stubs/Processor/stubs_MMU/: stubs_functions_MMU.cpp
    ../../../../DeviceCode/Drivers/Stubs/Processor/stubs_WATCHDOG/: stubs_functions_WATCHDOG.cpp
    ../../../../DeviceCode/Drivers/Stubs/VirtualKey/: virtualkey_stubs.cpp
  group Device-Common
    ../../../../DeviceCode/Initialization/: tinyhal.cpp OEM_Model_SKU_NetworkID.cpp
  group Crypto
    ../../../../Crypto/Stubs/: stubs.cpp
  group Startup
    ../../../../DeviceCode/Targets/Native/LPC43XX/DeviceCode/CortexM/TinyHal/RVD_S/: FirstEntry.s IDelayLoop.s VectorsHandlers.s
    ../../../../DeviceCode/Drivers/Stubs/Processor/stubs_PreStackInit/RVD_S/: PreStackInit_stub.s
  group Support
    ../../../../Support/WireProtocol/: Compression.cpp WireProtocol.cpp
    ../../../../Support/crc/: CRC.cpp
target TinyCLR - Debug (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: TinyCLR +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1
  c misc: --via=ccflags-debug.txt
  asm misc: --via=asflags-debug.txt
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x10080000 size 0x12000
  scatter file: TinyCLR.sct
  link misc: --via=ldflags-debug.txt
